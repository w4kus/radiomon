options:
  parameters:
    author: Mark White - W4KUS
    generate_options: qt_gui
    id: dmr_gui
    output_language: python
    title: DMR MODEM
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '441000000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: radio_samp_rate
  id: variable
  parameters:
    value: '1536000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Squelch
    start: '-60'
    step: '1'
    stop: '0'
    value: '-35'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: TED Gain
    start: '0'
    step: '0.005'
    stop: '1.0'
    value: '0.12'
  states: {}
- name: time_update
  id: variable
  parameters:
    value: '0.010'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: radio_samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1.0'
    threshold: squelch
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mark/Projects/dmr-mon/stuff/capture_rrc.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/mark/Projects/dmr-mon/stuff/capture_sync.bin
    type: float
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.04'
    max_dev: '1.0'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate / baud_rate
    ted_gain: ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: int(radio_samp_rate / samp_rate)
    gain: '0.2'
    samp_rate: radio_samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '64000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,1,2
    name: Input Spectrum
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 4,0,1,3
    label1: Demod
    name: RRC Filtered Signal
    size: '1024'
    srate: samp_rate
    type: float
    update_time: time_update
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 3,2,1,1
    label1: Demod
    name: Demodulated Signal
    size: '1024'
    srate: radio_samp_rate
    type: float
    update_time: time_update
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 2,0,1,3
    name: Clock Synchronized Signal
    size: '1024'
    srate: '10000'
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: time_update
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.001'
    decim: '1'
    gain: '1'
    ntaps: '32'
    samp_rate: samp_rate
    sym_rate: baud_rate*2
    type: fir_filter_fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: '30'
    samp_rate: radio_samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod_out
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:55000
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', high_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_3, '0']
- [digital_symbol_sync_xx_0, '0', zeromq_push_sink_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [high_pass_filter_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
